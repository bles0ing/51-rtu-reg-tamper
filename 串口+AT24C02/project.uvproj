# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c AT24C02.h AT24C02.c Delay.c Delay.h I2C.c I2C.h Key.c Key.h LCD1602.c LCD1602.h Uart.c Uart.h Timer0_Init.c Timer0_Init.h
